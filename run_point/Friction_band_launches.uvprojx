# Keil uVision project Friction_band_launches.uvprojx, settings and files
target Friction_band_launches (6210000::V6.21::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Friction_band_launches +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,DEBUG,STM32F429xx
  c include: .;Drivers\CMSIS\Core\Include;Drivers\STM32_HAL_Driver\Inc;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CSP\Config;Drivers\Bsp;User\Application\Inc;User\Utils;Middlewares\FreeRTOS\include;Middlewares\FreeRTOS\portable\GCC\ARM_CM4F
  asm define: USE_HAL_DRIVER,DEBUG,STM32F429xx
  memory RVCT1: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT7: RAM 0x10000000 size 0x10000
  group Utils
    User/Utils/ring_fifo/: ring_fifo.c
    User/Utils/: buffer_append.c
  group Middlewares/FreeRTOS/Portable
    Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS/Core
    Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/CSP
    Drivers/CSP/: UART_STM32F4xx.c CAN_STM32F4xx.c ETH_STM32F4xx.c I2C_STM32F4xx.c RTC_STM32F4xx.c SPI_STM32F4xx.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/CMSIS/Startup
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/HAL_Driver
    Drivers/STM32_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c
  group Application
    User/Application/Src/: main.c stm32f4xx_it.c rtos_tasks.c my_math.c pid.c shoot_machine.c uart2_calbackl.c msg_protocol.c remote_ctrl.c dji_angle.c
  group Bsp
    Drivers/Bsp/core/: bsp_core.c core_delay.c retarget_io.c
    Drivers/Bsp/key/: key.c
    Drivers/Bsp/led/: led.c
    Drivers/Bsp/: bsp.c
    Drivers/Bsp/AK-Motor/: ak_motor.c
    Drivers/Bsp/CAN/: can_list.c
    Drivers/Bsp/Damiao-Motor/: damiao.c
    Drivers/Bsp/DJI-Motor/: dji_bldc_motor.c
    Drivers/Bsp/VESC/: vesc_motor.c
